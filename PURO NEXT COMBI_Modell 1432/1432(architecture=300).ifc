Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: x:/temp/worker_COMMON_47/temp/tmp_2780_62_mTlyk/format_1/1432(architecture=300).ifc
Time: 2025-08-11T06:09:25
Made in: PARTsolutions

# IfcProject, 1432(architecture=300)
Description: PURO NEXT COMBI

# IfcDiscreteAccessory, 1432(architecture=300)
In: BUILDING
Description: 1432(architecture=300)
Pset_ManufacturerTypeInformation - Manufacturer: KALDEWEI; ArticleNumber: 1432
ePset_PARTsolutions - NB: 1432(architecture=300); NN: 1432; NT: PURO NEXT COMBI; NBSYN: $A.($LODDEST.=$LODLEVEL.); LINA: 1432(architecture=300); CATALOG: Kaldewei; LODLEVEL: 300; A: 1432; B: 1432.png; C: PURO NEXT COMBI; E: KALDEWEI; EF000049: 1600; EF004567: 700
